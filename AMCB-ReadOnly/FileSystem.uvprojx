# Keil uVision project FileSystem.uvprojx, settings and files
target FS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FileSystem
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: Main.cpp
  group File
    ./: File.cpp File.h
  group COM
    ./: UART.cpp UART.h
  group SPI
    ./: Card.cpp Card.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
