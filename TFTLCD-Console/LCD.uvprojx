# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: Main.cpp Status.cpp Status.h
  group LCD
    ./: LCD.cpp LCD.h
  group GUI
    ./: GUI.cpp ASCII.cpp ARC.cpp GUI.h ASCII.h ARC.h
  group COM
    ./: COM.cpp COM.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
