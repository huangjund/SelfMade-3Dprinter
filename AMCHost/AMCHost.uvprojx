# Keil uVision project AMCHost.uvprojx, settings and files
target AMCHost (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AMCHost
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: Main.cpp Automate.cpp Automate.h
  group ControlBus
    ./: CBUS.cpp SCONI.cpp CBUS.h SCONI.h TCONI.cpp TCONI.h
  group IOBus
    ./: IBUS.cpp IBUS.h FCONI.cpp FCONI.h CCONI.cpp CCONI.h
  group AuxBus
    ./: ABUS.cpp ABUS.h
  group Status
    ./: Status.cpp Status.h
  group Shell
    ./: Shell.cpp Shell.h Instruction.cpp Instruction.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
